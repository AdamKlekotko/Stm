# Keil uVision project inz.uvprojx, settings and files
target inz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: inz
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c main.c stm32f3xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_dac_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_flash.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_pwr.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_tim.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
